# IAR project LCD_new.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MDR32F1x MDR1986BE9x
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_ASSERT_INFO=2; __BYTE_ORDER__=__ORDER_LITTLE_ENDIAN__
  ICCARM.CCIncludePath2: CMSIS\Include; CMSIS\Device\Milandr\MDR32F9Qx\Include; MDRSPL\inc; Main\Include; CMSIS\cm3\CoreSupport; 
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: LCD_new.srec
  ILINK.IlinkOutputFile: LCD_new.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Milandr\MDR1986VE9x\MDR32F1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ./: lv_conf.h main.c
  group CMSIS
    CMSIS/Device/Milandr/MDR32F9Qx/Source/: startup_MDR32F9Qx.s system_MDR32F9Qx.c
  group lvgl
    lvgl/: lv_conf_templ.h lvgl.h
  group lvgl/docs
    lvgl/docs/: CODE_OF_CONDUCT.md CONTRIBUTING.md TODO_MAJOR.md TODO_MINOR.md TODO_PATCH.md
  group lvgl/lv_core
    lvgl/lv_core/: lv_core.mk lv_group.c lv_group.h lv_indev.c lv_indev.h lv_obj.c lv_obj.h lv_refr.c lv_refr.h lv_style.c lv_style.h lv_vdb.c lv_vdb.h
  group lvgl/lv_draw
    lvgl/lv_draw/: lv_draw.c lv_draw.h lv_draw.mk lv_draw_rbasic.c lv_draw_rbasic.h lv_draw_vbasic.c lv_draw_vbasic.h
  group lvgl/lv_hal
    lvgl/lv_hal/: lv_hal.h lv_hal.mk lv_hal_disp.c lv_hal_disp.h lv_hal_indev.c lv_hal_indev.h lv_hal_tick.c lv_hal_tick.h
  group lvgl/lv_misc
    lvgl/lv_misc/: lv_anim.c lv_anim.h lv_area.c lv_area.h lv_circ.c lv_circ.h lv_color.c lv_color.h lv_font.c lv_font.h lv_fs.c lv_fs.h lv_ll.c lv_ll.h lv_math.c lv_math.h lv_mem.c lv_mem.h lv_misc.mk lv_task.c lv_task.h lv_templ.c lv_templ.h lv_trigo.c lv_trigo.h lv_txt.c lv_txt.h lv_ufs.c lv_ufs.h
  group lvgl/lv_misc/lv_fonts
    lvgl/lv_misc/lv_fonts/: lv_font_dejavu_10.c lv_font_dejavu_10_cyrillic.c lv_font_dejavu_10_latin_sup.c lv_font_dejavu_20.c lv_font_dejavu_20_cyrillic.c lv_font_dejavu_20_latin_sup.c lv_font_dejavu_30.c lv_font_dejavu_30_cyrillic.c lv_font_dejavu_30_latin_sup.c lv_font_dejavu_40.c lv_font_dejavu_40_cyrillic.c lv_font_dejavu_40_latin_sup.c lv_font_symbol_10.c lv_font_symbol_20.c lv_font_symbol_30.c lv_font_symbol_40.c lv_fonts.mk lv_symbol_def.h
  group lvgl/lv_objx
    lvgl/lv_objx/: lv_bar.c lv_bar.h lv_btn.c lv_btn.h lv_btnm.c lv_btnm.h lv_cb.c lv_cb.h lv_chart.c lv_chart.h lv_cont.c lv_cont.h lv_ddlist.c lv_ddlist.h lv_gauge.c lv_gauge.h lv_img.c lv_img.h lv_kb.c lv_kb.h lv_label.c lv_label.h lv_led.c lv_led.h lv_line.c lv_line.h lv_list.c lv_list.h lv_lmeter.c lv_lmeter.h lv_mbox.c lv_mbox.h lv_objx.mk lv_objx_templ.c lv_objx_templ.h lv_page.c lv_page.h lv_roller.c lv_roller.h lv_slider.c lv_slider.h lv_sw.c lv_sw.h lv_ta.c lv_ta.h lv_tabview.c lv_tabview.h lv_win.c lv_win.h
  group lvgl/lv_themes
    lvgl/lv_themes/: lv_theme.c lv_theme.h lv_theme_alien.c lv_theme_alien.h lv_theme_default.c lv_theme_default.h lv_theme_material.c lv_theme_material.h lv_theme_mono.c lv_theme_mono.h lv_theme_night.c lv_theme_night.h lv_theme_templ.c lv_theme_templ.h lv_theme_zen.c lv_theme_zen.h lv_themes.mk
  group SPL
    MDRSPL/src/: MDR32F9Qx_adc.c MDR32F9Qx_port.c MDR32F9Qx_rst_clk.c MDR32F9Qx_timer.c
