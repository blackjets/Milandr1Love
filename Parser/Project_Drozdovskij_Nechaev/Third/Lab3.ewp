# IAR project Lab3.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MDR32F1x MDR1986BE9x
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_ASSERT_INFO=2
  ICCARM.CCIncludePath2: CMSIS\Include; CMSIS\Device\Milandr\MDR32F9Qx\Include; MDRSPL\inc; Main\Include; CMSIS\cm3\CoreSupport; 
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Lab3.srec
  ILINK.IlinkOutputFile: Lab3.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Milandr\MDR1986VE9x\MDR32F1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group CMSIS
    CMSIS/Device/Milandr/MDR32F9Qx/Source/: startup_MDR32F9Qx.s system_MDR32F9Qx.c
  group SPL
    MDRSPL/src/: MDR32F9Qx_adc.c MDR32F9Qx_port.c MDR32F9Qx_rst_clk.c MDR32F9Qx_timer.c
