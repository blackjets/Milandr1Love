# IAR project lab1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MDR32F1x MDR1986BE9x
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: cmsis\cm3\CoreSupport; cmsis\cm3\DeviceSupport\MDR32F9Qx\inc; CSMSIS\Device\Milandr\MDR32F9Qx\Include; mdr32f9qx_stdperiph_driver\inc; Config; cmsis
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lab1.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Milandr\MDR1986VE9x\MDR32F1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group cmsis
    cmsis/cm3/CoreSupport/: core_cm3-.h core_cm3.c stdint.h
    cmsis/cm3/DeviceSupport/MDR32F9Qx/inc/: MDR32Fx.h
    cmsis/cm3/DeviceSupport/MDR32F9Qx/startup/iar/: startup_MDR32F9Qx.s system_MDR32F9Qx.c system_MDR32F9Qx.h
  group gr1
    ./: main.c main.h
  group periph/inc
    mdr32f9qx_stdperiph_driver/inc/USB_Library/: 1986BE9x_usb_CDC.h 1986BE9x_usb_default_handlers.h 1986BE9x_usb_device.h MDR32F9Qx_usb_CDC.h MDR32F9Qx_usb_default_handlers.h MDR32F9Qx_usb_device.h MDR32F9Qx_usb_handlers.h
    mdr32f9qx_stdperiph_driver/inc/: MDR32F9Qx_adc.h MDR32F9Qx_arinc429r.h MDR32F9Qx_arinc429t.h MDR32F9Qx_audio.h MDR32F9Qx_bkp.h MDR32F9Qx_can.h MDR32F9Qx_comp.h MDR32F9Qx_dac.h MDR32F9Qx_dma.h MDR32F9Qx_ebc.h MDR32F9Qx_eeprom.h MDR32F9Qx_eth.h MDR32F9Qx_i2c.h MDR32F9Qx_iwdg.h MDR32F9Qx_keypad.h MDR32F9Qx_led.h MDR32F9Qx_lib.h MDR32F9Qx_mil_std_1553.h MDR32F9Qx_port.h MDR32F9Qx_power.h MDR32F9Qx_rst_clk.h MDR32F9Qx_ssp.h MDR32F9Qx_timer.h MDR32F9Qx_uart.h MDR32F9Qx_usb.h MDR32F9Qx_wwdg.h
  group periph/src
    mdr32f9qx_stdperiph_driver/src/: MDR32F9Qx_adc.c MDR32F9Qx_arinc429r.c MDR32F9Qx_arinc429t.c MDR32F9Qx_audio.c MDR32F9Qx_bkp.c MDR32F9Qx_can.c MDR32F9Qx_comp.c MDR32F9Qx_dac.c MDR32F9Qx_dma.c MDR32F9Qx_ebc.c MDR32F9Qx_eeprom.c MDR32F9Qx_i2c.c MDR32F9Qx_iwdg.c MDR32F9Qx_keypad.c MDR32F9Qx_led.c MDR32F9Qx_port.c MDR32F9Qx_power.c MDR32F9Qx_rst_clk.c MDR32F9Qx_ssp.c MDR32F9Qx_timer.c MDR32F9Qx_uart.c MDR32F9Qx_usb.c MDR32F9Qx_wwdg.c
